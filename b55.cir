* /home/ameya/eSim-Workspace/b55/b55.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Wed Aug 12 20:06:13 2020

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R2  /vdd Net-_R2-Pad2_ 10
R3  Net-_R2-Pad2_ Net-_R3-Pad2_ 10
R4  Net-_R3-Pad2_ Net-_R4-Pad2_ 10
VrefH1  /vdd GND 3.3
v1  d0 GND pulse
R5  Net-_R4-Pad2_ Net-_R5-Pad2_ 10
R6  Net-_R5-Pad2_ Net-_R6-Pad2_ 10
R7  Net-_R6-Pad2_ Net-_R7-Pad2_ 10
R8  Net-_R7-Pad2_ Net-_R8-Pad2_ 10
X1  d5 /vdd Net-_R8-Pad2_ Net-_R7-Pad2_ Net-_X1-Pad6_ swi
X5  d5 /vdd Net-_R6-Pad2_ Net-_R5-Pad2_ Net-_X17-Pad5_ swi
X13  d5 /vdd Net-_R4-Pad2_ Net-_R3-Pad2_ Net-_X13-Pad6_ swi
X4  d5 /vdd Net-_R2-Pad2_ /vdd Net-_X16-Pad5_ swi
R9  Net-_R8-Pad2_ Net-_R10-Pad1_ 10
R10  Net-_R10-Pad1_ Net-_R10-Pad2_ 10
R11  Net-_R10-Pad2_ Net-_R11-Pad2_ 10
X6  d5 /vdd Net-_R10-Pad2_ Net-_R10-Pad1_ Net-_X18-Pad5_ swi
R12  Net-_R11-Pad2_ Net-_R12-Pad2_ 10
R13  Net-_R12-Pad2_ Net-_R13-Pad2_ 10
R14  Net-_R13-Pad2_ Net-_R14-Pad2_ 10
R15  Net-_R14-Pad2_ Net-_R15-Pad2_ 10
R16  Net-_R15-Pad2_ Net-_R16-Pad2_ 10
R17  Net-_R16-Pad2_ Net-_R17-Pad2_ 10
R18  Net-_R17-Pad2_ Net-_R18-Pad2_ 10
X2  d5 /vdd Net-_R18-Pad2_ Net-_R17-Pad2_ Net-_X2-Pad6_ swi
X8  d5 /vdd Net-_R16-Pad2_ Net-_R15-Pad2_ Net-_X19-Pad4_ swi
X14  d5 /vdd Net-_R14-Pad2_ Net-_R13-Pad2_ Net-_X14-Pad6_ swi
X7  d5 /vdd Net-_R12-Pad2_ Net-_R11-Pad2_ Net-_X18-Pad4_ swi
R19  Net-_R18-Pad2_ Net-_R19-Pad2_ 10
R20  Net-_R19-Pad2_ Net-_R20-Pad2_ 10
R21  Net-_R20-Pad2_ Net-_R21-Pad2_ 10
R22  Net-_R21-Pad2_ Net-_R22-Pad2_ 10
R23  Net-_R22-Pad2_ Net-_R23-Pad2_ 10
R24  Net-_R23-Pad2_ Net-_R24-Pad2_ 10
R25  Net-_R24-Pad2_ Net-_R25-Pad2_ 10
R26  Net-_R25-Pad2_ Net-_R26-Pad2_ 10
R27  Net-_R26-Pad2_ Net-_R27-Pad2_ 10
R28  Net-_R27-Pad2_ Net-_R28-Pad2_ 10
X3  d5 /vdd Net-_R28-Pad2_ Net-_R27-Pad2_ Net-_X22-Pad4_ swi
X11  d5 /vdd Net-_R26-Pad2_ Net-_R25-Pad2_ Net-_X11-Pad6_ swi
X15  d5 /vdd Net-_R24-Pad2_ Net-_R23-Pad2_ Net-_X15-Pad6_ swi
X10  d5 /vdd Net-_R22-Pad2_ Net-_R21-Pad2_ Net-_X10-Pad6_ swi
R29  Net-_R28-Pad2_ Net-_R29-Pad2_ 10
R30  Net-_R29-Pad2_ Net-_R30-Pad2_ 10
R31  Net-_R30-Pad2_ Net-_R31-Pad2_ 10
X12  d5 /vdd Net-_R30-Pad2_ Net-_R29-Pad2_ Net-_X12-Pad6_ swi
R32  Net-_R31-Pad2_ h1 10
X16  d6 /vdd Net-_X13-Pad6_ Net-_X16-Pad5_ Net-_X16-Pad6_ swi
X17  d6 /vdd Net-_X1-Pad6_ Net-_X17-Pad5_ Net-_X17-Pad6_ swi
X18  d6 /vdd Net-_X18-Pad4_ Net-_X18-Pad5_ Net-_X18-Pad6_ swi
X19  d6 /vdd Net-_X19-Pad4_ Net-_X14-Pad6_ Net-_X19-Pad6_ swi
X20  d6 /vdd Net-_X20-Pad4_ Net-_X2-Pad6_ Net-_X20-Pad6_ swi
X21  d6 /vdd Net-_X15-Pad6_ Net-_X10-Pad6_ Net-_X21-Pad6_ swi
X22  d6 /vdd Net-_X22-Pad4_ Net-_X11-Pad6_ Net-_X22-Pad6_ swi
X24  d7 /vdd Net-_X17-Pad6_ Net-_X16-Pad6_ Net-_X24-Pad6_ swi
X25  d7 /vdd Net-_X19-Pad6_ Net-_X18-Pad6_ Net-_X25-Pad6_ swi
X26  d7 /vdd Net-_X21-Pad6_ Net-_X20-Pad6_ Net-_X26-Pad6_ swi
X27  d7 /vdd Net-_X23-Pad6_ Net-_X22-Pad6_ Net-_X27-Pad6_ swi
X28  d8 /vdd Net-_X25-Pad6_ Net-_X24-Pad6_ Net-_X28-Pad6_ swi
X29  d8 /vdd Net-_X27-Pad6_ Net-_X26-Pad6_ Net-_X29-Pad6_ swi
X30  d9 /vdd Net-_X29-Pad6_ Net-_X28-Pad6_ /out1 swi
X23  d6 /vdd Net-_X23-Pad4_ Net-_X12-Pad6_ Net-_X23-Pad6_ swi
R33  h1 Net-_R33-Pad2_ 10
R34  Net-_R33-Pad2_ Net-_R34-Pad2_ 10
R35  Net-_R34-Pad2_ Net-_R35-Pad2_ 10
R36  Net-_R35-Pad2_ Net-_R36-Pad2_ 10
R37  Net-_R36-Pad2_ Net-_R37-Pad2_ 10
R38  Net-_R37-Pad2_ Net-_R38-Pad2_ 10
R39  Net-_R38-Pad2_ Net-_R39-Pad2_ 10
R40  Net-_R39-Pad2_ Net-_R40-Pad2_ 10
X31  d0 /vdd Net-_R40-Pad2_ Net-_R39-Pad2_ Net-_X31-Pad6_ swi
X35  d0 /vdd Net-_R38-Pad2_ Net-_R37-Pad2_ Net-_X35-Pad6_ swi
X43  d0 /vdd Net-_R36-Pad2_ Net-_R35-Pad2_ Net-_X43-Pad6_ swi
X34  d0 /vdd Net-_R34-Pad2_ Net-_R33-Pad2_ Net-_X34-Pad6_ swi
R41  Net-_R40-Pad2_ Net-_R41-Pad2_ 10
R42  Net-_R41-Pad2_ Net-_R42-Pad2_ 10
R43  Net-_R42-Pad2_ Net-_R43-Pad2_ 10
X36  d0 /vdd Net-_R42-Pad2_ Net-_R41-Pad2_ Net-_X36-Pad6_ swi
R44  Net-_R43-Pad2_ Net-_R44-Pad2_ 10
R45  Net-_R44-Pad2_ Net-_R45-Pad2_ 10
R46  Net-_R45-Pad2_ Net-_R46-Pad2_ 10
R47  Net-_R46-Pad2_ Net-_R47-Pad2_ 10
R48  Net-_R47-Pad2_ Net-_R48-Pad2_ 10
R49  Net-_R48-Pad2_ Net-_R49-Pad2_ 10
R50  Net-_R49-Pad2_ Net-_R50-Pad2_ 10
X32  d0 /vdd Net-_R50-Pad2_ Net-_R49-Pad2_ Net-_X32-Pad6_ swi
X38  d0 /vdd Net-_R48-Pad2_ Net-_R47-Pad2_ Net-_X38-Pad6_ swi
X44  d0 /vdd Net-_R46-Pad2_ Net-_R45-Pad2_ Net-_X44-Pad6_ swi
X37  d0 /vdd Net-_R44-Pad2_ Net-_R43-Pad2_ Net-_X37-Pad6_ swi
R51  Net-_R50-Pad2_ Net-_R51-Pad2_ 10
R52  Net-_R51-Pad2_ Net-_R52-Pad2_ 10
R53  Net-_R52-Pad2_ Net-_R53-Pad2_ 10
X39  d0 /vdd Net-_R52-Pad2_ Net-_R51-Pad2_ Net-_X39-Pad6_ swi
R54  Net-_R53-Pad2_ Net-_R54-Pad2_ 10
R55  Net-_R54-Pad2_ Net-_R55-Pad2_ 10
R56  Net-_R55-Pad2_ Net-_R56-Pad2_ 10
R57  Net-_R56-Pad2_ Net-_R57-Pad2_ 10
R58  Net-_R57-Pad2_ Net-_R58-Pad2_ 10
R59  Net-_R58-Pad2_ Net-_R59-Pad2_ 10
R60  Net-_R59-Pad2_ Net-_R60-Pad2_ 10
X33  d0 /vdd Net-_R60-Pad2_ Net-_R59-Pad2_ Net-_X33-Pad6_ swi
X41  d0 /vdd Net-_R58-Pad2_ Net-_R57-Pad2_ Net-_X41-Pad6_ swi
X45  d0 /vdd Net-_R56-Pad2_ Net-_R55-Pad2_ Net-_X45-Pad6_ swi
X40  d0 /vdd Net-_R54-Pad2_ Net-_R53-Pad2_ Net-_X40-Pad6_ swi
R61  Net-_R60-Pad2_ Net-_R61-Pad2_ 10
R62  Net-_R61-Pad2_ Net-_R62-Pad2_ 10
R63  Net-_R62-Pad2_ Net-_R63-Pad2_ 10
X42  d0 /vdd Net-_R62-Pad2_ Net-_R61-Pad2_ Net-_X42-Pad6_ swi
R64  Net-_R63-Pad2_ GND 10
X46  d1 /vdd Net-_X43-Pad6_ Net-_X34-Pad6_ Net-_X46-Pad6_ swi
X47  d1 /vdd Net-_X31-Pad6_ Net-_X35-Pad6_ Net-_X47-Pad6_ swi
X48  d1 /vdd Net-_X37-Pad6_ Net-_X36-Pad6_ Net-_X48-Pad6_ swi
X49  d1 /vdd Net-_X38-Pad6_ Net-_X44-Pad6_ Net-_X49-Pad6_ swi
X50  d1 /vdd Net-_X39-Pad6_ Net-_X32-Pad6_ Net-_X50-Pad6_ swi
X51  d1 /vdd Net-_X45-Pad6_ Net-_X40-Pad6_ Net-_X51-Pad6_ swi
X52  d1 /vdd Net-_X33-Pad6_ Net-_X41-Pad6_ Net-_X52-Pad6_ swi
X54  d2 /vdd Net-_X47-Pad6_ Net-_X46-Pad6_ Net-_X54-Pad6_ swi
X55  d2 /vdd Net-_X49-Pad6_ Net-_X48-Pad6_ Net-_X55-Pad6_ swi
X56  d2 /vdd Net-_X51-Pad6_ Net-_X50-Pad6_ Net-_X56-Pad6_ swi
X57  d2 /vdd Net-_X53-Pad6_ Net-_X52-Pad6_ Net-_X57-Pad6_ swi
X58  d3 /vdd Net-_X55-Pad6_ Net-_X54-Pad6_ Net-_X58-Pad6_ swi
X59  d3 /vdd Net-_X57-Pad6_ Net-_X56-Pad6_ Net-_X59-Pad6_ swi
X60  d4 /vdd Net-_X59-Pad6_ Net-_X58-Pad6_ /out2 swi
X53  d1 /vdd Net-_R63-Pad2_ Net-_X42-Pad6_ Net-_X53-Pad6_ swi
R1  h1 Net-_R1-Pad2_ 10
X61  d5 /vdd h1 Net-_R31-Pad2_ Net-_X23-Pad4_ swi
v3  d1 GND pulse
v4  d2 GND pulse
v5  d3 GND pulse
v6  d4 GND pulse
v7  d5 GND pulse
v8  d6 GND pulse
v9  d7 GND pulse
v10  d8 GND pulse
v11  d9 GND pulse
C2  /out1 GND 1p
C1  /out2 GND 1p
v2  Net-_R1-Pad2_ GND DC
X9  d5 /vdd Net-_R20-Pad2_ Net-_R19-Pad2_ Net-_X20-Pad4_ swi
U3  /out1 GND plot_v2
U1  /out2 GND plot_v2
U2  /aout plot_v1
C3  /aout GND 1p
R65  /out1 Net-_R65-Pad2_ 10k
R66  /out2 Net-_R66-Pad2_ 10k
R67  Net-_R65-Pad2_ /aout 10k
X62  GND GND Net-_R66-Pad2_ Net-_R65-Pad2_ GND /vdd /aout opamp_2
R68  Net-_R66-Pad2_ /aout 10k

.end
